EXTRA_OEMESON:append = " \
    -Derror_cap=1000 \
    -Derror_info_cap=1000 \
"
